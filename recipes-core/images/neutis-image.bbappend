#IMAGE_INSTALL_append += "qt-example"
#IMAGE_INSTALL_append += "alsa-utils"

